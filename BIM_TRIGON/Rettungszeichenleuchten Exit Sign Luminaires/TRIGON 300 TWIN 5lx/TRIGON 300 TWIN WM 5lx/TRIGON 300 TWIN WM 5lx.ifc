Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 03a0854e-4659-40cb-9e90-aba3a406d188, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: TRIGON 300 TWIN WM 5lx.ifc
Time: 2025-12-09T14:26:48+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: TRIGON 300 TWIN WM 5lx:TRIGON 300 TWIN WM 5lx - Einzelbatterie, TRIGON 300 TWIN WM 5lx:TRIGON 300 TWIN WM 5lx - Einzelbatterie:2518115
In: Default
Type - Material: Stahlblech - RAL9016, Kunststoff - PMMA, Kunststoff -PVC, Vorgabe(1)
Type - Pset_ElementShading - Color: white
Material: Vorgabe(1)
Pset_DistributionFlowElementCommon - Reference: TRIGON 300 TWIN WM 5lx - Einzelbatterie; sets with these values: 2
